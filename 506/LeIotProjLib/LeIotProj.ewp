# IAR project LeIotProj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None; default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B; __IEEE_LITTLE_ENDIAN; RTK8710_FLASH_2M
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\adapter\inc; ..\rtk8710_sdk\component\os\freertos; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\include; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\rtk8710_sdk\component\os\os_dep\include; ..\rtk8710_sdk\component\common\api\network\include; ..\rtk8710_sdk\component\common\api; ..\rtk8710_sdk\component\common\api\at_cmd; ..\rtk8710_sdk\component\common\api\platform; ..\rtk8710_sdk\component\common\api\wifi; ..\rtk8710_sdk\component\common\api\wifi\rtw_wpa_supplicant\src; ..\rtk8710_sdk\component\common\api\wifi\rtw_wowlan; ..\rtk8710_sdk\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant; ..\rtk8710_sdk\component\common\application; ..\rtk8710_sdk\component\common\application\mqtt\MQTTClient; ..\rtk8710_sdk\component\common\application\mqtt\MQTTPacket; ..\rtk8710_sdk\component\common\example; ..\rtk8710_sdk\component\common\example\wlan_fast_connect; ..\rtk8710_sdk\component\common\drivers\modules; ..\rtk8710_sdk\component\common\drivers\sdio\realtek\sdio_host\inc; ..\rtk8710_sdk\component\common\drivers\inic\rtl8711b; ..\rtk8710_sdk\component\common\drivers\usb_class\device; ..\rtk8710_sdk\component\common\drivers\usb_class\device\class; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\include; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\osdep; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\hci; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\hal; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\hal\rtl8711b; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\rtk8710_sdk\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\rtk8710_sdk\component\common\network; ..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\include; ..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\include; ..\rtk8710_sdk\component\common\network\ssl\ssl_ram_map\rom; ..\rtk8710_sdk\component\common\test; ..\rtk8710_sdk\component\common\utilities; ..\rtk8710_sdk\component\soc\realtek\8711b\app\monitor\include; ..\rtk8710_sdk\component\soc\realtek\8711b\cmsis; ..\rtk8710_sdk\component\soc\realtek\8711b\cmsis\device; ..\rtk8710_sdk\component\soc\realtek\8711b\fwlib; ..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\include; ..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\crypto; ..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\rom_lib; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\os_dep\include; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\std_lib\include; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\std_lib\libc\include; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\std_lib\libc\rom\string; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\std_lib\libgcc\rtl8195a\include; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\rtl_lib; ..\rtk8710_sdk\component\soc\realtek\8711b\misc; ..\rtk8710_sdk\component\soc\realtek\8711b\misc\os; ..\rtk8710_sdk\component\common\mbed\api; ..\rtk8710_sdk\component\common\mbed\hal; ..\rtk8710_sdk\component\common\mbed\hal_ext; ..\rtk8710_sdk\component\common\mbed\targets\cmsis\rtl8711b; ..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b; ..\rtk8710_sdk\component\common\network\coap\include; ..\iot_sdk\include; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Demo\Common\include; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\rtk8710_sdk\component\soc\realtek\8711b\cmsis; ..\rtk8710_sdk\component\soc\realtek\8711b\swlib\os_dep\include; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\include; ..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: LeIotProj.srec
  prebuild: CSCRIPT  "..\rtk8710_sdk\component\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x080F4000"
  postbuild: CSCRIPT  "..\rtk8710_sdk\component\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --pi_veneers
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app/uart_adapter
    ../rtk8710_sdk/component/common/application/uart_adapter/: uart_adapter.c
  group cmsis
    ../rtk8710_sdk/component/soc/realtek/8711b/cmsis/device/: app_start.c
    ../rtk8710_sdk/component/soc/realtek/8711b/fwlib/ram_lib/: startup.c
  group console
    ../rtk8710_sdk/component/common/api/at_cmd/: atcmd_lwip.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../rtk8710_sdk/component/soc/realtek/8711b/app/monitor/ram/: low_level_io.c monitor.c rtl_consol.c rtl_trace.c
  group leiot/include
    ../iot_sdk/include/: datatype.h device.h iotplatform_log.h iotsdk.h iotsdk_ota.h iotsdk_wifi.h log.h rtos.h security_func.h
  group leiot/iotlib
    ../iot_sdk/lib/: libledmrtos.a
  group leiot/rtk8710/adapter
    ../adapter/: adapter.h device.c factory_cycle_task.c factory_cycle_task.h factory_event_task.c factory_event_task.h factory_net_task.c factory_net_task.h main.c udp_task.c udp_task.h wifi_utils.c wifi_utils.h
  group leiot/rtk8710/adapter/inc
    ../adapter/inc/: build_info.h FreeRTOSConfig.h main.h platform_autoconf.h platform_opts.h
  group leiot/rtk8710/adapter_lib
    ../adapter_lib/: flash.c flash.h hal_event.h lamp_effect.c lamp_effect.h report_task.c report_task.h schema_task.c schema_task.h
  group leiot/rtk8710/driver
    ../driver/: hal_key.c hal_key.h keyboard.c keyboard.h led.c led.h relay.c relay.h wifi_door_lock_uart_driver.c wifi_door_lock_uart_driver.h
  group leiot/rtk8710/product
    ../product/: hal_dev.c hal_dev.h message_queue.c message_queue.h product_config.h protocol.c protocol.h protocol_config.h version.h wifi_door_lock.c wifi_door_lock.h
  group lib
    ../rtk8710_sdk/component/soc/realtek/8711b/misc/bsp/lib/common/IAR/: lib_http.a lib_mdns.a lib_platform.a lib_rtlstd.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a lib_xmodem.a
  group network/api
    ../rtk8710_sdk/component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../rtk8710_sdk/component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../rtk8710_sdk/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_wps_config.c
  group network/app
    ../rtk8710_sdk/component/common/api/network/src/: ping_test.c wlan_network.c
    ../rtk8710_sdk/component/common/utilities/: ssl_client.c tcptest.c
  group network/coap
    ../rtk8710_sdk/component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../rtk8710_sdk/component/common/application/google/: google_tls.c
  group network/http
    ../rtk8710_sdk/component/common/network/httpc/: httpc_tls.c
    ../rtk8710_sdk/component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../rtk8710_sdk/component/common/network/dhcp/: dhcps.c
  group network/lwip/api
    ../rtk8710_sdk/component/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../rtk8710_sdk/component/common/network/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/core/ipv4
    ../rtk8710_sdk/component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/netif
    ../rtk8710_sdk/component/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group network/lwip/port
    ../rtk8710_sdk/component/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../rtk8710_sdk/component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../rtk8710_sdk/component/common/network/mDNS/: mDNSPlatform.c
  group network/polarssl/polarssl
    ../rtk8710_sdk/component/common/network/ssl/polarssl-1.3.8/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c debug.c ecp_ram.c entropy.c entropy_poll.c error.c gcm.c havege.c md2.c md4.c memory_buffer_alloc.c net.c padlock.c pbkdf2.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../rtk8710_sdk/component/common/network/ssl/polarssl-1.3.8/include/polarssl/: x509_crt.h
  group network/polarssl/ssl_ram_map
    ../rtk8710_sdk/component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group network/sntp
    ../rtk8710_sdk/component/common/network/sntp/: sntp.c sntp.h
  group network/wsclient
    ../rtk8710_sdk/component/common/network/websocket/: libwsclient.h wsclient_api.h wsclient_tls.c
  group os/freertos
    ../rtk8710_sdk/component/os/freertos/: cmsis_os.c freertos_service.c
    ../rtk8710_sdk/component/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue1.c tasks.c timers.c
  group os/freertos/portable
    ../rtk8710_sdk/component/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
    ../rtk8710_sdk/component/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group os/osdep
    ../rtk8710_sdk/component/os/os_dep/: device_lock.c osdep_service.c
  group peripheral/api
    ../rtk8710_sdk/component/common/mbed/targets/hal/rtl8711b/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/rtl8710b
    ../rtk8710_sdk/component/soc/realtek/8711b/fwlib/ram_lib/: rtl8710b_dsleepcfg.c rtl8710b_dstandbycfg.c rtl8710b_intfcfg.c rtl8710b_pinmapcfg.c rtl8710b_sleepcfg.c
  group peripheral/wlan
    ../rtk8710_sdk/component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_power_by_rate.c rtw_opt_power_limit.c rtw_opt_skbuf.c
  group utilities
    ../rtk8710_sdk/component/common/utilities/: http_client.c uart_socket.c webserver.c xml.c
    ../rtk8710_sdk/component/common/application/xmodem/: uart_fw_update.c
  group utilities/example
    ../rtk8710_sdk/component/common/example/bcast/: example_bcast.c
    ../rtk8710_sdk/component/common/example/coap/: example_coap.c
    ../rtk8710_sdk/component/common/example/eap/: example_eap.c
    ../rtk8710_sdk/component/common/example/: example_entry.c
    ../rtk8710_sdk/component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../rtk8710_sdk/component/common/example/googlenest/: example_google.c
    ../rtk8710_sdk/component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../rtk8710_sdk/component/common/example/http_client/: example_http_client.c
    ../rtk8710_sdk/component/common/example/http_download/: example_http_download.c
    ../rtk8710_sdk/component/common/example/httpc/: example_httpc.c
    ../rtk8710_sdk/component/common/example/httpd/: example_httpd.c
    ../rtk8710_sdk/component/common/example/inic_gspi/: example_inic_gspi.c
    ../rtk8710_sdk/component/common/example/mcast/: example_mcast.c
    ../rtk8710_sdk/component/common/example/mdns/: example_mdns.c
    ../rtk8710_sdk/component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../rtk8710_sdk/component/common/example/rarp/: example_rarp.c
    ../rtk8710_sdk/component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../rtk8710_sdk/component/common/example/socket_select/: example_socket_select.c
    ../rtk8710_sdk/component/common/example/ssl_download/: example_ssl_download.c
    ../rtk8710_sdk/component/common/example/ssl_server/: example_ssl_server.c
    ../rtk8710_sdk/component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../rtk8710_sdk/component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../rtk8710_sdk/component/common/example/uart_firmware_update/: example_uart_update.c
    ../rtk8710_sdk/component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../rtk8710_sdk/component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../rtk8710_sdk/component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../rtk8710_sdk/component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../rtk8710_sdk/component/common/example/websocket/: example_wsclient.c
    ../rtk8710_sdk/component/common/example/xml/: example_xml.c
  group utilities/wigadget
    ../rtk8710_sdk/component/common/application/wigadget/: cloud_link.c shtc1.c wigadget.c
