<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>uart_adapter</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\uart_adapter\uart_adapter.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>cmsis</name>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\cmsis\device\app_start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\startup.c</name>
    </file>
  </group>
  <group>
    <name>console</name>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\at_cmd\atcmd_lwip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\at_cmd\atcmd_sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\at_cmd\atcmd_wifi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\at_cmd\log_service.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\app\monitor\ram\low_level_io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\app\monitor\ram\monitor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\app\monitor\ram\rtl_consol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\app\monitor\ram\rtl_trace.c</name>
    </file>
  </group>
  <group>
    <name>leiot</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\datatype.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\device.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\iotplatform_log.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\iotsdk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\iotsdk_ota.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\iotsdk_wifi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\log.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\rtos.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\include\security_func.h</name>
      </file>
    </group>
    <group>
      <name>iotlib</name>
      <file>
        <name>$PROJ_DIR$\..\iot_sdk\lib\libledmrtos.a</name>
      </file>
    </group>
    <group>
      <name>rtk8710</name>
      <group>
        <name>adapter</name>
        <group>
          <name>inc</name>
          <file>
            <name>$PROJ_DIR$\..\adapter\inc\build_info.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\adapter\inc\FreeRTOSConfig.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\adapter\inc\main.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\adapter\inc\platform_autoconf.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\adapter\inc\platform_opts.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\adapter\adapter.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\device.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_cycle_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_cycle_task.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_event_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_event_task.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_net_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\factory_net_task.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\udp_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\udp_task.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\wifi_utils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter\wifi_utils.h</name>
        </file>
      </group>
      <group>
        <name>adapter_lib</name>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\hal_event.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\lamp_effect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\lamp_effect.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\report_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\report_task.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\schema_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\adapter_lib\schema_task.h</name>
        </file>
      </group>
      <group>
        <name>driver</name>
        <file>
          <name>$PROJ_DIR$\..\driver\hal_key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\hal_key.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\keyboard.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\keyboard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\led.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\relay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\relay.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\wifi_door_lock_uart_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\driver\wifi_door_lock_uart_driver.h</name>
        </file>
      </group>
      <group>
        <name>product</name>
        <file>
          <name>$PROJ_DIR$\..\product\hal_dev.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\hal_dev.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\message_queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\message_queue.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\product_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\protocol.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\protocol.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\protocol_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\version.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\wifi_door_lock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\product\wifi_door_lock.h</name>
        </file>
      </group>
      <configuration>
        <name>Debug</name>
      </configuration>
    </group>
    <configuration>
      <name>Debug</name>
      <settings>
        <name>RuntimeChecking</name>
        <data>
          <version>2</version>
          <wantNonLocal>0</wantNonLocal>
          <debug>1</debug>
          <option>
            <name>GenRtcTrackPointerBounds</name>
            <state>1</state>
          </option>
          <option>
            <name>GenRtcCheckAccesses</name>
            <state>1</state>
          </option>
          <option>
            <name>GenRtcGenerateEntries</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcIntOverflow</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcIncUnsigned</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcIntConversion</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcInclExplicit</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcIntShiftOverflow</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcInclUnsignedShiftOverflow</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcUnhandledCase</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcDivByZero</name>
            <state>0</state>
          </option>
          <option>
            <name>GenRtcCheckPtrsNonInstrFunc</name>
            <state>1</state>
          </option>
        </data>
      </settings>
    </configuration>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_http.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_mdns.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_platform.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_rtlstd.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_websocket.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wlan.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wlan_mp.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wps.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_xmodem.a</name>
    </file>
  </group>
  <group>
    <name>network</name>
    <group>
      <name>api</name>
      <group>
        <name>wifi</name>
        <group>
          <name>rtw_wpa_supplicant</name>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_eap_config.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_wps_config.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\wifi_conf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\wifi_ind.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\wifi_promisc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\wifi_simple_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\wifi\wifi_util.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\lwip_netconf.c</name>
      </file>
    </group>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\network\src\ping_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\ssl_client.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\tcptest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\api\network\src\wlan_network.c</name>
      </file>
    </group>
    <group>
      <name>coap</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\coap\sn_coap_ameba_port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\coap\sn_coap_builder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\coap\sn_coap_header_check.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\coap\sn_coap_parser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\coap\sn_coap_protocol.c</name>
      </file>
    </group>
    <group>
      <name>googlenest</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\google\google_tls.c</name>
      </file>
    </group>
    <group>
      <name>http</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\httpc\httpc_tls.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\httpd\httpd_tls.c</name>
      </file>
    </group>
    <group>
      <name>lwip</name>
      <group>
        <name>api</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\api_lib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\api_msg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\err.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\netbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\netdb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\netifapi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\sockets.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\api\tcpip.c</name>
        </file>
      </group>
      <group>
        <name>core</name>
        <group>
          <name>ipv4</name>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\autoip.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\icmp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\igmp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet_chksum.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_addr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_frag.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\def.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\dhcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\dns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\lwip_timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\memp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\netif.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\pbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\raw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\stats.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\tcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_in.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_out.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\core\udp.c</name>
        </file>
      </group>
      <group>
        <name>netif</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\src\netif\etharp.c</name>
        </file>
      </group>
      <group>
        <name>port</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\ethernetif.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\osdep\lwip_intf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\sys_arch.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\dhcp\dhcps.c</name>
      </file>
    </group>
    <group>
      <name>mdns</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\mDNS\mDNSPlatform.c</name>
      </file>
    </group>
    <group>
      <name>polarssl</name>
      <group>
        <name>polarssl</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\aesni.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\blowfish.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\camellia.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ccm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\certs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\cipher.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\cipher_wrap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ecp_ram.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\entropy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\entropy_poll.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\error.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\gcm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\havege.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\md2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\md4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\memory_buffer_alloc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\net.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\padlock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\pbkdf2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\pkcs11.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\pkcs12.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\pkcs5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\pkparse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ripemd160.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ssl_cache.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ssl_ciphersuites.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ssl_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ssl_srv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\ssl_tls.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\threading.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\timing.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\version.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\version_features.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509_create.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509_crl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509_crt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\include\polarssl\x509_crt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509_csr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509write_crt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\x509write_csr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\polarssl-1.3.8\library\xtea.c</name>
        </file>
      </group>
      <group>
        <name>ssl_ram_map</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\ssl\ssl_ram_map\ssl_ram_map.c</name>
        </file>
      </group>
      <configuration>
        <name>Debug</name>
      </configuration>
    </group>
    <group>
      <name>sntp</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\sntp\sntp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\sntp\sntp.h</name>
      </file>
    </group>
    <group>
      <name>wsclient</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\websocket\libwsclient.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\websocket\wsclient_api.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\network\websocket\wsclient_tls.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>os</name>
    <group>
      <name>freertos</name>
      <group>
        <name>portable</name>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\portable\MemMang\heap_5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F\port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F\portasm.s</name>
          <configuration>
            <name>Debug</name>
          </configuration>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_service.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\queue1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\freertos\freertos_v8.1.2\Source\timers.c</name>
      </file>
    </group>
    <group>
      <name>osdep</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\os_dep\device_lock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\os\os_dep\osdep_service.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>peripheral</name>
    <group>
      <name>api</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\analogin_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\dma_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\efuse_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\flash_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\gpio_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\gpio_irq_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\i2c_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\i2s_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\nfc_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\pinmap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\pinmap_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\port_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\pwmout_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\rtc_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\serial_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\sleep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\spi_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\sys_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\timer_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\us_ticker.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\us_ticker_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\wait_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\mbed\targets\hal\rtl8711b\wdt_api.c</name>
      </file>
    </group>
    <group>
      <name>rtl8710b</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_dsleepcfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_dstandbycfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_intfcfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_pinmapcfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_sleepcfg.c</name>
      </file>
    </group>
    <group>
      <name>wlan</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_power_by_rate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_power_limit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_skbuf.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>utilities</name>
    <group>
      <name>example</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\bcast\example_bcast.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\coap\example_coap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\eap\example_eap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\example_entry.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\get_beacon_frame\example_get_beacon_frame.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\googlenest\example_google.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\high_load_memory_use\example_high_load_memory_use.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\http_client\example_http_client.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\http_download\example_http_download.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\httpc\example_httpc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\httpd\example_httpd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\inic_gspi\example_inic_gspi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\mcast\example_mcast.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\mdns\example_mdns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\nonblock_connect\example_nonblock_connect.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\rarp\example_rarp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\sntp_showtime\example_sntp_showtime.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\socket_select\example_socket_select.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\ssl_download\example_ssl_download.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\ssl_server\example_ssl_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\tcp_keepalive\example_tcp_keepalive.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\uart_atcmd\example_uart_atcmd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\uart_firmware_update\example_uart_update.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\wifi_mac_monitor\example_wifi_mac_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\wifi_roaming\example_wifi_roaming.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\wlan_fast_connect\example_wlan_fast_connect.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\wlan_scenario\example_wlan_scenario.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\websocket\example_wsclient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\example\xml\example_xml.c</name>
      </file>
    </group>
    <group>
      <name>wigadget</name>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\wigadget\cloud_link.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\wigadget\shtc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\wigadget\wigadget.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\http_client.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\application\xmodem\uart_fw_update.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\uart_socket.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\webserver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\rtk8710_sdk\component\common\utilities\xml.c</name>
    </file>
  </group>
</project>


